# Repository VoltixTeam/Voltix_SensorShield

File README.md:

# Voltix Sensor Shield Hardware Design Files

The Voltix Sensor Shield adds a microphone, an accelerometer and a temperature and humidty sensor to the [Voltix Board](https://github.com/VoltixTeam/Voltix_Board).

Latest design files:
 - [Schematics](https://voltix-docs.vercel.app/artifacts/sensor_shield/latest/schematics.pdf)
 - [Layout](https://voltix-docs.vercel.app/artifacts/sensor_shield/latest/pcb.pdf)
 - [3D rendering](https://voltix-docs.vercel.app/artifacts/sensor_shield/latest/3drendering.png)

## Sensors

The has the following sensors:
 - Bosch BMA400 digital accelerometer
 - Sensirion SHTC3 temperature and humidity sensor
 - Vesper VM1010 analog output microphone

## KiCad design kicad/voltix-sensor-shield.kicad_pcb

Parts:
C1, C2, C4, C5, C7: 0.1u; C_0805_2012Metric; MPN CL21B104MACNNNC
C3: DNP; C_0805_2012Metric; not fitted
C6: 2.2n; C_0805_2012Metric; MPN 885012207088
J1: Conn_01x10; PinSocket_1x10_P2.54mm_Vertical; MPN PRT-11376
J2: Conn_01x12; PinSocket_1x12_P2.54mm_Vertical; MPN PRT-14322
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2, JP3: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm_NoMsk
Q1: Q_PMOS_GSD; DIODES_SOT-23-3; MPN DMG2301L-7
R1, R2, R3: 18k; R_0805_2012Metric; MPN RC0805FR-0718KL
R4, R6: 1M; R_0805_2012Metric; MPN RMCF0805FG1M00
R5: 680k; R_0805_2012Metric; MPN RC0805FR-07680KL
R7, R8: 750R; R_0805_2012Metric; MPN RC0805FR-07750RL
U1: BMA400; BOS_BMA400; MPN BMA400
U2: SHTC3; SEN_SHTC3; MPN SHTC3
U3: VM1010; VES_VM1010; MPN PMM-3738-VM1010-R

Connections:
/AoutMic: C7.1, J1.7, R8.2
/BMA_AddSelect: JP1.1 (A), JP2.2 (B), U1.1 (SDO)
/BMA_Int: J1.3, U1.5 (INT1)
/BiasMic: J1.6, JP3.1 (A)
/DoutMic: J1.5, U3.7 (dout)
/ModeMic: J2.11, U3.5 (mode)
/PowerEnable: J1.4, R6.1, R7.1
/SCL: J1.1, R1.2, U1.12 (SCX), U2.2 (SCL)
/SDA: J1.2, R2.2, U1.2 (SDX), U2.3 (SDA)
/VccMic: C5.1, Q1.3 (D), R4.2, U3.6 (Vdd)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.10, J2.2, J2.12, JP2.1 (A), R5.1, U1.8 (GNDIO), U1.9 (GND), U2.4 (VSS), U2.5 (PAD), U3.4 (Vss2), U3.8 (Vss1)
unnamed: C3.1, J2.4
unnamed: C6.1, JP3.2 (B), R4.1, R5.2
unnamed: Q1.1 (G), R7.2
unnamed: R3.1, U3.3 (GA1)
unnamed: R3.2, U3.2 (GA2)
unnamed: R8.1, U3.1 (Vout)
VCC: C1.1, C2.1, C4.1, J2.6, JP1.2 (B), Q1.2 (S), R1.1, R2.1, R6.2, U1.3 (VDDIO), U1.7 (VDD), U1.10 (CSB), U2.1 (VDD)

Notes on the sheet:
0.81V bias voltage Settles to 99% within 4ms
2.12 kHz LP

Board: 2 copper layers, 55.9 x 22.9 mm, 24 parts (0 on the bottom side), 18 nets.

## Commit log

2024-06-26 add anonymized content
